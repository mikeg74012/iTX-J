# IAR project New product.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xE GD GD32F303xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: New product.srec
  ILINK.IlinkOutputFile: New product.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: acceldriver.c assgabsgas.c batterycharger.c batterymonitor.c buttonmonitor.c config.c configupdate.c console.c Crc16.c Crc32.c crcdriver.c csp.c DetectEvent.c EventStore.c fitment.c flash.c gasgauge.c gd32f30x_it.c gnssComms.c gnssevent.c GsmAudio.c GsmBle.c gsmComms.c GsmGnss.c GsmGprs.c GsmHttp.c GsmSms.c GsmTcp.c GsmUtils.c GsmVoice.c hardwareVersion.c i2c.c led.c lowpowersupport.c main.c MessageQueue.c Messages.c misc.c Modem.c motionbuffer.c motionmonitor.c ota.c OtaHttp.c OtaSerial.c post.c power.c ringbuffer.c rtc.c SeqEmergency.c SeqHeartbeat.c SeqJourney.c SeqReport.c Sequencer.c serialram.c SmsMessages.c spi.c Statistics.c StatusLog.c task_switch.s TestMode.c threads.c Uart.c watchdog.c wifi.c xtimer.c xyzfilter.c
